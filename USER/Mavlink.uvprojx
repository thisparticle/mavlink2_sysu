# Keil uVision project Mavlink.uvprojx, settings and files
target Mavlink (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c misc: --c99 --no_strict --gnu
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\FWLIB\inc;..\mavlink;..\mavlink\common;..\HARDWARE\RTC;..\mavlink;..\HARDWARE\LCD;..\USMART
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: stm32f4xx_it.c main.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/LCD/: lcd.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_pwr.c stm32f4xx_rtc.c stm32f4xx_tim.c
  group README
    ../: readme.txt
  group mavlink
    ../mavlink/: checksum.h define.h math_utils.h mavlink.h mavlink_aes.c mavlink_aes.h mavlink_avoid_errors.h mavlink_conversions.h mavlink_get_info.h mavlink_helpers.h mavlink_msg_cm_zdfx.h mavlink_msg_dn_fxsj.h mavlink_msg_dn_ykqsj.h mavlink_msg_test_types.h mavlink_sha256.h mavlink_types.h mavlink_usart_fifo.c mavlink_usart_fifo.h protocol.h sysu.h testsuite.h version.h generic_port.h serial_port.h udp_port.h sysu_mavlink.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
